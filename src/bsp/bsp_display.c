/*
 * MIPI-DSI display bring-up for the Waveshare ESP32-P4-WIFI6-Touch-LCD-4B.
 *
 * The 4B ships with one of two 720x720 panels; Waveshare's factory firmware
 * reads the DCS ID and picks the matching init sequence. Same here:
 *   ST7703   : DCS ID 38 21 1F
 *   JD9365DA : page-1 ID registers 8D/8E = 93 65
 *
 * Init tables and timings are copied from Waveshare's sources
 * (esp_lcd_st7703 vendor_specific_init_default, MIT / Apache-2.0, and
 *  waveshare_boards jd9365_720_720_init.h, Apache-2.0).
 */
#include <string.h>
#include "bsp_board.h"
#include "esp_check.h"
#include "esp_log.h"
#include "esp_ldo_regulator.h"
#include "esp_lcd_mipi_dsi.h"
#include "esp_lcd_panel_io.h"
#include "esp_lcd_panel_commands.h"
#include "driver/gpio.h"
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"

static const char *TAG = "bsp_display";

typedef struct {
    uint8_t cmd;
    const uint8_t *data;
    uint8_t len;
    uint16_t delay_ms;
} lcd_init_cmd_t;

/* ------------------------------------------------------------ ST7703 init */
static const lcd_init_cmd_t st7703_init_cmds[] = {
    {0xB9, (uint8_t[]){0xF1, 0x12, 0x83}, 3, 0},
    {0xB1, (uint8_t[]){0x00, 0x00, 0x00, 0xDA, 0x80}, 5, 0},
    {0xB2, (uint8_t[]){0x3C, 0x12, 0x30}, 3, 0},
    {0xB3, (uint8_t[]){0x10, 0x10, 0x28, 0x28, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00}, 10, 0},
    {0xB4, (uint8_t[]){0x80}, 1, 0},
    {0xB5, (uint8_t[]){0x0A, 0x0A}, 2, 0},
    {0xB6, (uint8_t[]){0x97, 0x97}, 2, 0},
    {0xB8, (uint8_t[]){0x26, 0x22, 0xF0, 0x13}, 4, 0},
    {0xBA, (uint8_t[]){0x31, 0x81, 0x0F, 0xF9, 0x0E, 0x06, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x44, 0x25, 0x00, 0x90, 0x0A, 0x00, 0x00, 0x01, 0x4F, 0x01, 0x00, 0x00, 0x37}, 27, 0},
    {0xBC, (uint8_t[]){0x47}, 1, 0},
    {0xBF, (uint8_t[]){0x02, 0x11, 0x00}, 3, 0},
    {0xC0, (uint8_t[]){0x73, 0x73, 0x50, 0x50, 0x00, 0x00, 0x12, 0x70, 0x00}, 9, 0},
    {0xC1, (uint8_t[]){0x25, 0x00, 0x32, 0x32, 0x77, 0xE4, 0xFF, 0xFF, 0xCC, 0xCC, 0x77, 0x77}, 12, 0},
    {0xC6, (uint8_t[]){0x82, 0x00, 0xBF, 0xFF, 0x00, 0xFF}, 6, 0},
    {0xC7, (uint8_t[]){0xB8, 0x00, 0x0A, 0x10, 0x01, 0x09}, 6, 0},
    {0xC8, (uint8_t[]){0x10, 0x40, 0x1E, 0x02}, 4, 0},
    {0xCC, (uint8_t[]){0x0B}, 1, 0},
    {0xE0, (uint8_t[]){0x00, 0x0B, 0x10, 0x2C, 0x3D, 0x3F, 0x42, 0x3A, 0x07, 0x0D, 0x0F, 0x13, 0x15, 0x13, 0x14, 0x0F, 0x16, 0x00, 0x0B, 0x10, 0x2C, 0x3D, 0x3F, 0x42, 0x3A, 0x07, 0x0D, 0x0F, 0x13, 0x15, 0x13, 0x14, 0x0F, 0x16}, 34, 0},
    {0xE3, (uint8_t[]){0x07, 0x07, 0x0B, 0x0B, 0x0B, 0x0B, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xC0, 0x10}, 14, 0},
    {0xE9, (uint8_t[]){0xC8, 0x10, 0x0A, 0x00, 0x00, 0x80, 0x81, 0x12, 0x31, 0x23, 0x4F, 0x86, 0xA0, 0x00, 0x47, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x98, 0x02, 0x8B, 0xAF, 0x46, 0x02, 0x88, 0x88, 0x88, 0x88, 0x88, 0x98, 0x13, 0x8B, 0xAF, 0x57, 0x13, 0x88, 0x88, 0x88, 0x88, 0x88, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}, 63, 0},
    {0xEA, (uint8_t[]){0x97, 0x0C, 0x09, 0x09, 0x09, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9F, 0x31, 0x8B, 0xA8, 0x31, 0x75, 0x88, 0x88, 0x88, 0x88, 0x88, 0x9F, 0x20, 0x8B, 0xA8, 0x20, 0x64, 0x88, 0x88, 0x88, 0x88, 0x88, 0x23, 0x00, 0x00, 0x02, 0x71, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x80, 0x81, 0x00, 0x00, 0x00, 0x00}, 61, 0},
    {0xEF, (uint8_t[]){0xFF, 0xFF, 0x01}, 3, 0},
    {0x11, (uint8_t[]){0x00}, 1, 250},
    {0x29, (uint8_t[]){0x00}, 1, 50},
};

/* ----------------------------------------------------------- JD9365 init */
/* "LCD-4B 8904ANT 720x720 panel: preserve its power, gamma and GOA mapping." */
#define R(c, v) {c, (uint8_t[]){v}, 1, 0}
static const lcd_init_cmd_t jd9365_init_cmds[] = {
    /* Page 0: unlock + 2-lane */
    R(0xE0, 0x00), R(0xE1, 0x93), R(0xE2, 0x65), R(0xE3, 0xF8), R(0x80, 0x01),
    /* Page 1: power, timing, gamma */
    R(0xE0, 0x01),
    R(0x00, 0x00), R(0x01, 0x85), R(0x03, 0x00), R(0x04, 0x73),
    R(0x17, 0x00), R(0x18, 0xBF), R(0x19, 0x00), R(0x1A, 0x00), R(0x1B, 0xBF), R(0x1C, 0x00),
    R(0x1F, 0x7E), R(0x20, 0x24), R(0x21, 0x24), R(0x22, 0x4E), R(0x24, 0xFE),
    R(0x37, 0x09), R(0x38, 0x04), R(0x3C, 0x76), R(0x3D, 0xFF), R(0x3E, 0xFF), R(0x3F, 0x7F),
    R(0x40, 0x04), R(0x41, 0x5A), R(0x44, 0x11),
    R(0x55, 0x02), R(0x56, 0x01), R(0x57, 0x69), R(0x58, 0x09), R(0x59, 0xEA), R(0x5A, 0x1E), R(0x5B, 0x1E),
    R(0x5D, 0x78), R(0x5E, 0x64), R(0x5F, 0x54), R(0x60, 0x48), R(0x61, 0x43), R(0x62, 0x35),
    R(0x63, 0x3A), R(0x64, 0x24), R(0x65, 0x3D), R(0x66, 0x3C), R(0x67, 0x3C), R(0x68, 0x5C),
    R(0x69, 0x4D), R(0x6A, 0x56), R(0x6B, 0x49), R(0x6C, 0x45), R(0x6D, 0x37), R(0x6E, 0x25),
    R(0x6F, 0x0F),
    R(0x70, 0x78), R(0x71, 0x64), R(0x72, 0x54), R(0x73, 0x48), R(0x74, 0x43), R(0x75, 0x35),
    R(0x76, 0x3A), R(0x77, 0x24), R(0x78, 0x3D), R(0x79, 0x3C), R(0x7A, 0x3C), R(0x7B, 0x5C),
    R(0x7C, 0x4D), R(0x7D, 0x56), R(0x7E, 0x49), R(0x7F, 0x45), R(0x80, 0x37), R(0x81, 0x25),
    R(0x82, 0x0F),
    /* Page 2: GOA and panel timing */
    R(0xE0, 0x02),
    R(0x00, 0x35), R(0x01, 0x5F), R(0x02, 0x40), R(0x03, 0x42), R(0x04, 0x5F), R(0x05, 0x17),
    R(0x06, 0x18), R(0x07, 0x5E), R(0x08, 0x48), R(0x09, 0x4A), R(0x0A, 0x44), R(0x0B, 0x46),
    R(0x0C, 0x5F), R(0x0D, 0x5F), R(0x0E, 0x5F), R(0x0F, 0x5F), R(0x10, 0x5F), R(0x11, 0x5F),
    R(0x12, 0x5F), R(0x13, 0x5F), R(0x14, 0x5F), R(0x15, 0x5F),
    R(0x16, 0x35), R(0x17, 0x5F), R(0x18, 0x41), R(0x19, 0x43), R(0x1A, 0x5F), R(0x1B, 0x17),
    R(0x1C, 0x18), R(0x1D, 0x5E), R(0x1E, 0x49), R(0x1F, 0x4B), R(0x20, 0x45), R(0x21, 0x47),
    R(0x22, 0x5F), R(0x23, 0x5F), R(0x24, 0x5F), R(0x25, 0x5F), R(0x26, 0x5F), R(0x27, 0x5F),
    R(0x28, 0x5F), R(0x29, 0x5F), R(0x2A, 0x5F), R(0x2B, 0x5F),
    R(0x2C, 0x35), R(0x2D, 0x5E), R(0x2E, 0x43), R(0x2F, 0x41), R(0x30, 0x5F), R(0x31, 0x17),
    R(0x32, 0x18), R(0x33, 0x5F), R(0x34, 0x47), R(0x35, 0x45), R(0x36, 0x4B), R(0x37, 0x49),
    R(0x38, 0x5F), R(0x39, 0x5F), R(0x3A, 0x5F), R(0x3B, 0x5F), R(0x3C, 0x5F), R(0x3D, 0x5F),
    R(0x3E, 0x5F), R(0x3F, 0x5F), R(0x40, 0x5F), R(0x41, 0x5F),
    R(0x42, 0x35), R(0x43, 0x5E), R(0x44, 0x42), R(0x45, 0x40), R(0x46, 0x5F), R(0x47, 0x17),
    R(0x48, 0x18), R(0x49, 0x5F), R(0x4A, 0x46), R(0x4B, 0x44), R(0x4C, 0x4A), R(0x4D, 0x48),
    R(0x4E, 0x5F), R(0x4F, 0x5F), R(0x50, 0x5F), R(0x51, 0x5F), R(0x52, 0x5F), R(0x53, 0x5F),
    R(0x54, 0x5F), R(0x55, 0x5F), R(0x56, 0x5F), R(0x57, 0x5F),
    R(0x58, 0x40), R(0x59, 0x00), R(0x5A, 0x00), R(0x5B, 0x30), R(0x5C, 0x07), R(0x5D, 0x30),
    R(0x5E, 0x01), R(0x5F, 0x02), R(0x60, 0x40), R(0x61, 0x01), R(0x62, 0x02), R(0x63, 0x06),
    R(0x64, 0x68), R(0x65, 0x42), R(0x66, 0xE5), R(0x67, 0x73), R(0x68, 0x0B), R(0x69, 0x06),
    R(0x6A, 0x68), R(0x6B, 0x08), R(0x6C, 0x00), R(0x6D, 0x08), R(0x6E, 0x08), R(0x6F, 0x08),
    R(0x70, 0x00), R(0x71, 0x00), R(0x72, 0x06), R(0x73, 0x68), R(0x74, 0x00), R(0x75, 0xF8),
    R(0x76, 0x00), R(0x77, 0xAA), R(0x78, 0xDF), R(0x79, 0xE1), R(0x7A, 0x06), R(0x7B, 0x00),
    R(0x7C, 0x00), R(0x7D, 0x03), R(0x7E, 0x7B), R(0x81, 0x20), R(0x83, 0xD6),
    /* Back to page 0, power on */
    R(0xE0, 0x00), R(0xE6, 0x02), R(0xE7, 0x02),
    {0x11, (uint8_t[]){0x00}, 1, 120},
    {0x29, (uint8_t[]){0x00}, 1, 20},
};
#undef R

static bsp_panel_kind_t s_panel_kind = BSP_PANEL_UNKNOWN;
static esp_lcd_panel_handle_t s_panel = NULL;

bsp_panel_kind_t bsp_display_panel_kind(void) { return s_panel_kind; }

static void panel_hw_reset(void)
{
    gpio_config_t cfg = {
        .pin_bit_mask = 1ULL << BSP_LCD_RST_GPIO,
        .mode = GPIO_MODE_OUTPUT,
    };
    gpio_config(&cfg);
    gpio_set_level(BSP_LCD_RST_GPIO, 1);
    vTaskDelay(pdMS_TO_TICKS(5));
    gpio_set_level(BSP_LCD_RST_GPIO, 0);
    vTaskDelay(pdMS_TO_TICKS(10));
    gpio_set_level(BSP_LCD_RST_GPIO, 1);
    vTaskDelay(pdMS_TO_TICKS(120));
}

static bsp_panel_kind_t panel_probe(esp_lcd_panel_io_handle_t io)
{
    uint8_t id[3] = {0};
    esp_err_t err = esp_lcd_panel_io_rx_param(io, 0x04, id, sizeof(id));
    ESP_LOGI(TAG, "DCS ID: %02X %02X %02X (%s)", id[0], id[1], id[2], esp_err_to_name(err));
    if (err == ESP_OK && id[0] == 0x38 && id[1] == 0x21 && id[2] == 0x1F) {
        return BSP_PANEL_ST7703;
    }

    /* JD9365: unlock the manufacturer command set, read page-1 ID */
    static const uint8_t unlock[][2] = {
        {0xE0, 0x00}, {0xE1, 0x93}, {0xE2, 0x65}, {0xE3, 0xF8}, {0xE0, 0x01},
    };
    for (size_t i = 0; i < sizeof(unlock) / sizeof(unlock[0]); i++) {
        esp_lcd_panel_io_tx_param(io, unlock[i][0], &unlock[i][1], 1);
    }
    uint8_t jd[2] = {0};
    esp_lcd_panel_io_rx_param(io, 0x8D, &jd[0], 1);
    esp_lcd_panel_io_rx_param(io, 0x8E, &jd[1], 1);
    esp_lcd_panel_io_tx_param(io, 0xE0, (uint8_t[]){0x00}, 1);   /* back to page 0 */
    ESP_LOGI(TAG, "JD9365 ID: %02X %02X", jd[0], jd[1]);
    if (jd[0] == 0x93 && jd[1] == 0x65) {
        return BSP_PANEL_JD9365;
    }
    ESP_LOGW(TAG, "Panel not identified, assuming ST7703");
    return BSP_PANEL_ST7703;
}

static esp_err_t send_init_cmds(esp_lcd_panel_io_handle_t io, const lcd_init_cmd_t *cmds, size_t n)
{
    for (size_t i = 0; i < n; i++) {
        ESP_RETURN_ON_ERROR(esp_lcd_panel_io_tx_param(io, cmds[i].cmd, cmds[i].data, cmds[i].len),
                            TAG, "send cmd 0x%02X failed", cmds[i].cmd);
        if (cmds[i].delay_ms) {
            vTaskDelay(pdMS_TO_TICKS(cmds[i].delay_ms));
        }
    }
    return ESP_OK;
}

esp_err_t bsp_display_new(esp_lcd_panel_handle_t *ret_panel)
{
    ESP_RETURN_ON_FALSE(ret_panel, ESP_ERR_INVALID_ARG, TAG, "null arg");
    if (s_panel) {
        *ret_panel = s_panel;
        return ESP_OK;
    }

    /* 1. Power the MIPI D-PHY */
    static esp_ldo_channel_handle_t ldo = NULL;
    esp_ldo_channel_config_t ldo_cfg = {
        .chan_id = BSP_MIPI_DPHY_LDO_CHAN,
        .voltage_mv = BSP_MIPI_DPHY_LDO_MV,
    };
    ESP_RETURN_ON_ERROR(esp_ldo_acquire_channel(&ldo_cfg, &ldo), TAG, "LDO acquire failed");

    /* 2. DSI bus + DBI command interface */
    esp_lcd_dsi_bus_handle_t dsi_bus = NULL;
    esp_lcd_dsi_bus_config_t bus_cfg = {
        .bus_id = 0,
        .num_data_lanes = BSP_LCD_DSI_LANES,
#if CONFIG_ESP32P4_SELECTS_REV_LESS_V3
        /* Pre-v3 silicon: _DEFAULT is XTAL, which only v3+ supports -> abort() */
        .phy_clk_src = MIPI_DSI_PHY_PLLREF_CLK_SRC_DEFAULT_LEGACY,
#else
        .phy_clk_src = MIPI_DSI_PHY_PLLREF_CLK_SRC_DEFAULT,
#endif
        .lane_bit_rate_mbps = BSP_LCD_DSI_LANE_MBPS,
    };
    ESP_RETURN_ON_ERROR(esp_lcd_new_dsi_bus(&bus_cfg, &dsi_bus), TAG, "DSI bus failed");

    esp_lcd_panel_io_handle_t io = NULL;
    esp_lcd_dbi_io_config_t dbi_cfg = {
        .virtual_channel = 0,
        .lcd_cmd_bits = 8,
        .lcd_param_bits = 8,
    };
    ESP_RETURN_ON_ERROR(esp_lcd_new_panel_io_dbi(dsi_bus, &dbi_cfg, &io), TAG, "DBI IO failed");

    /* 3. Reset + identify the panel */
    panel_hw_reset();
    s_panel_kind = panel_probe(io);

    /* 4. DPI (video) panel with timing for the detected controller */
    esp_lcd_dpi_panel_config_t dpi_cfg = {
        .virtual_channel = 0,
        .dpi_clk_src = MIPI_DSI_DPI_CLK_SRC_DEFAULT,
        .in_color_format = LCD_COLOR_FMT_RGB565,
        .out_color_format = LCD_COLOR_FMT_RGB565,
        .num_fbs = 1,
        .video_timing = {
            .h_size = BSP_LCD_H_RES,
            .v_size = BSP_LCD_V_RES,
        },
        .flags.use_dma2d = true,
    };
    if (s_panel_kind == BSP_PANEL_JD9365) {
        /* 240/7 MHz is exactly reachable from PLL_F240M (Waveshare note) */
        dpi_cfg.dpi_clock_freq_mhz = 240.0f / 7.0f;
        dpi_cfg.video_timing.hsync_pulse_width = 24;
        dpi_cfg.video_timing.hsync_back_porch = 30;
        dpi_cfg.video_timing.hsync_front_porch = 30;
        dpi_cfg.video_timing.vsync_pulse_width = 2;
        dpi_cfg.video_timing.vsync_back_porch = 16;
        dpi_cfg.video_timing.vsync_front_porch = 12;
    } else {
        dpi_cfg.dpi_clock_freq_mhz = 38;
        dpi_cfg.video_timing.hsync_pulse_width = 20;
        dpi_cfg.video_timing.hsync_back_porch = 50;
        dpi_cfg.video_timing.hsync_front_porch = 50;
        dpi_cfg.video_timing.vsync_pulse_width = 4;
        dpi_cfg.video_timing.vsync_back_porch = 20;
        dpi_cfg.video_timing.vsync_front_porch = 20;
    }
    esp_lcd_panel_handle_t panel = NULL;
    ESP_RETURN_ON_ERROR(esp_lcd_new_panel_dpi(dsi_bus, &dpi_cfg, &panel), TAG, "DPI panel failed");

    /* 5. Vendor init over DBI (LP mode), mirroring the esp_lcd_st7703 /
     *    esp_lcd_jd9365 drivers, then start the video stream. */
    if (s_panel_kind == BSP_PANEL_JD9365) {
        ESP_LOGI(TAG, "Initialising JD9365DA");
        esp_lcd_panel_io_tx_param(io, 0xE0, (uint8_t[]){0x00}, 1);              /* page 0 */
        esp_lcd_panel_io_tx_param(io, LCD_CMD_MADCTL, (uint8_t[]){0x00}, 1);
        esp_lcd_panel_io_tx_param(io, LCD_CMD_COLMOD, (uint8_t[]){0x55}, 1);    /* 16 bpp */
        esp_lcd_panel_io_tx_param(io, 0x80, (uint8_t[]){0x01}, 1);              /* 2 lanes */
        ESP_RETURN_ON_ERROR(send_init_cmds(io, jd9365_init_cmds,
                                           sizeof(jd9365_init_cmds) / sizeof(jd9365_init_cmds[0])),
                            TAG, "JD9365 init failed");
    } else {
        ESP_LOGI(TAG, "Initialising ST7703");
        esp_lcd_panel_io_tx_param(io, LCD_CMD_MADCTL, (uint8_t[]){0x00}, 1);
        ESP_RETURN_ON_ERROR(send_init_cmds(io, st7703_init_cmds,
                                           sizeof(st7703_init_cmds) / sizeof(st7703_init_cmds[0])),
                            TAG, "ST7703 init failed");
    }
    ESP_RETURN_ON_ERROR(esp_lcd_panel_init(panel), TAG, "DPI start failed");

    s_panel = panel;
    *ret_panel = panel;
    return ESP_OK;
}
